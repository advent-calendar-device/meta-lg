PACKAGECONFIG:remove = "vulkan"