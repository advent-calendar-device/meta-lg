PACKAGECONFIG:append = " eglfs kms gbm gles2"
PACKAGECONFIG:remove = " xcb wayland"