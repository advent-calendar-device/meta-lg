FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://kconfig.cfg"